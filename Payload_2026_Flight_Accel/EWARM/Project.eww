<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Payload 2026 Flight Accel.ewp</path>
  </project>
  <batchBuild />
</workspace>
